Solar Cell I-V Characteristics

* Including Solar cell subcircuit
.include Solar_Cell.txt

* Circuit connections
Vs 1 0 dc 20
R1 1 2 100
X1 2 0 solar_cell

.control

* Plot settings
set color0 = white
set color1 = black
set color2 = red

************ T = 35 *************

* Setting the temperature
set temp=35
dc vs -2 2 0.01

* I-V Plot
print -i(Vs) v(2) > IV_light_35.txt
print i(Vs)*v(2) v(2) > IV_light_power_35.txt

* Measuring cutin voltage (1mA)
meas dc cutin find v(2) when i(Vs) = 1m

* Measuring Isc and Vsc
meas dc Isc find i(Vs) when v(2) = 0
meas dc Voc find v(2) when i(Vs) = 0

* Measuring Im and Vm
let derivout = deriv(v(2)*i(Vs))
meas dc Im find i(Vs) when derivout = 0
meas dc Vm find v(2) when derivout = 0

* Measuring FF
let FF = (Im*Vm)/(Isc*Voc)
print FF

************ T = 45 *************

* Setting the temperature
set temp=45
dc vs -2 2 0.01

* I-V Plot
print -i(Vs) v(2) > IV_light_45.txt
print i(Vs)*v(2) v(2) > IV_light_power_45.txt

* Measuring cutin voltage (1mA)
meas dc cutin find v(2) when i(Vs) = 1m

* Measuring Isc and Vsc
meas dc Isc find i(Vs) when v(2) = 0
meas dc Voc find v(2) when i(Vs) = 0

* Measuring Im and Vm
let derivout = deriv(v(2)*i(Vs))
meas dc Im find i(Vs) when derivout = 0
meas dc Vm find v(2) when derivout = 0

* Measuring FF
let FF = (Im*Vm)/(Isc*Voc)
print FF

************ T = 55 *************

* Setting the temperature
set temp=55
dc vs -2 2 0.01

* I-V Plot
print -i(Vs) v(2) > IV_light_55.txt
print i(Vs)*v(2) v(2) > IV_light_power_55.txt

* Measuring cutin voltage (1mA)
meas dc cutin find v(2) when i(Vs) = 1m

* Measuring Isc and Vsc
meas dc Isc find i(Vs) when v(2) = 0
meas dc Voc find v(2) when i(Vs) = 0

* Measuring Im and Vm
let derivout = deriv(v(2)*i(Vs))
meas dc Im find i(Vs) when derivout = 0
meas dc Vm find v(2) when derivout = 0

* Measuring FF
let FF = (Im*Vm)/(Isc*Voc)
print FF

************ T = 65 *************

* Setting the temperature
set temp=65
dc vs -2 2 0.01

* I-V Plot
print -i(Vs) v(2) > IV_light_65.txt
print i(Vs)*v(2) v(2) > IV_light_power_65.txt

* Measuring cutin voltage (1mA)
meas dc cutin find v(2) when i(Vs) = 1m

* Measuring Isc and Vsc
meas dc Isc find i(Vs) when v(2) = 0
meas dc Voc find v(2) when i(Vs) = 0

* Measuring Im and Vm
let derivout = deriv(v(2)*i(Vs))
meas dc Im find i(Vs) when derivout = 0
meas dc Vm find v(2) when derivout = 0

* Measuring FF
let FF = (Im*Vm)/(Isc*Voc)
print FF

************ T = 75 *************

* Setting the temperature
set temp=75
dc vs -2 2 0.01

* I-V Plot
print -i(Vs) v(2) > IV_light_75.txt
print i(Vs)*v(2) v(2) > IV_light_power_75.txt

* Measuring cutin voltage (1mA)
meas dc cutin find v(2) when i(Vs) = 1m

* Measuring Isc and Vsc
meas dc Isc find i(Vs) when v(2) = 0
meas dc Voc find v(2) when i(Vs) = 0

* Measuring Im and Vm
let derivout = deriv(v(2)*i(Vs))
meas dc Im find i(Vs) when derivout = 0
meas dc Vm find v(2) when derivout = 0

* Measuring FF
let FF = (Im*Vm)/(Isc*Voc)
print FF

.endc
.end
